Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, FMHandOverView]
File name: Project Number
Time: 2019-11-29T10:34:21
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170419_0315(x64) - Exporter 17.0.1128.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Nov 29 10:34:21 2019 * Host: DEGTL09122 * Database: C:\Users\deschvi\AppData\Local\Temp\{5FBF2255-C897-414D-AB4B-43757415B546}\ifc * Database version: 5507 * Database creation date: Fri Nov 29 10:34:20 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Nov 29 10:34:21 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Nov 29 10:34:21 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: 22764026_D_11105810_H7640BM_OBSW, 11105810_D_H7640BM_OBSW:22764026_D_11105810_H7640BM_OBSW:205945
In: Level 1
Type - Material: z_Miele_Design_Steel_Chrom, z_Miele_Design_OBSW, z_Miele_Connection_Electric, z_Miele_Design_Zinc_Steel
Pset_BuildingElementProxyCommon - Reference: 22764026_D_11105810_H7640BM_OBSW
Pset_ManufacturerTypeInformation - Manufacturer: Miele
